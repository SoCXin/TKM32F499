# Keil uVision project UART.uvprojx, settings and files
target UART (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: UART +hex
  AfterMake: fromelf.exe --bin -o  ..//@L.bin  ./obj/@L.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\CMSIS_and_startup;..\CMSIS_and_startup\CMSIS;..\Hal_lib\inc;.\bsp;.\bsp\UART;.\bsp\sys;.\bsp\timer;.\bsp\GPIO;.\bsp\ADC
  memory RVCT4: ROM 0x70020000 size 0x200000
  memory RVCT9: RAM 0x70220000 size 0x5dffff
  group CMSIS_and_startup
    ../CMSIS_and_startup/: startup_Tk499.s tk499.h sys.c
  group bsp
    ./bsp/: main.c
    ./bsp/UART/: UART.c
    ./bsp/timer/: timer.c
    ./bsp/GPIO/: GPIO.c
    ./bsp/ADC/: ADC.c
  group hal_lib
    ../Hal_lib/src/: HAL_gpio.c HAL_rcc.c HAL_uart.c HAL_misc.c HAL_tim.c HAL_dma.c HAL_exti.c
