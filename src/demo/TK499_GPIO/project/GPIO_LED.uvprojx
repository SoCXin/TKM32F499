# Keil uVision project GPIO_LED.uvprojx, settings and files
target TK499_GPIO_LED (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: GPIO_LED +hex
  AfterMake: fromelf.exe --bin -o  ..//@L.bin  ./obj/@L.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\CMSIS_and_startup;..\CMSIS_and_startup\CMSIS;..\Hal_lib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x70020000 size 0x200000
  memory RVCT9: RAM 0x70220000 size 0x5dffff
  group StartUp
    ../CMSIS_and_startup/: startup_Tk499.s tk499.h sys.c
  group bsp
    ./bsp/: main.c
  group hal_lib
    ../Hal_lib/src/: HAL_gpio.c HAL_rcc.c
